## build/Kconfig/Kconfig.soc.arch
```kconfig
osource "C:/Users/eivin/ncs/v1.5.0/zephyr/soc/$(ARCH)/Kconfig"
osource "C:/Users/eivin/ncs/v1.5.0/zephyr/soc/$(ARCH)/*/Kconfig"
```
